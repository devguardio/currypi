# Repository devguardio/currypi (continued)

## KiCad design currypi.kicad_pcb (continued)

Parts:
C1, C8: 100uF; C_1206_3216Metric; JLC# C312983
C2, C3, C4, C9, C10, C11, C12, C13: 10uF; C_0805_2012Metric; JLC# C15850
C6, C14, C15, C16: 100nF; C_0402_1005Metric; JLC# C1525
D5, D6: LED; LED_0603_1608Metric
J2, J3: DF40HC_3.0_-100DS-0.4V_51_PNP_OVERLAY; HRS_DF40HC(3.0)-100DS-0.4V(58)_PNP_OVERLAY; Manufacturer_Part_Number DF40HC(3.0)-100DS-0.4V(51; Mouser Part Number 798-DF40HC30100DS451
JP2, JP3, JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R7: 1k; R_0402_1005Metric
R12, R13, R14: 470; R_0402_1005Metric; JLC# C25117
U1: rpi_cm4
U2: m.2_pcie_nvme; JLC# C364435

Connections:
/C1/3V3: C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, U2.2 (3V3), U2.4 (3V3), U2.12 (3V3), U2.14 (3V3), U2.16 (3V3), U2.18 (3V3), U2.70 (3V3), U2.72 (3V3), U2.74 (3V3); also elsewhere on the board
/C1/3V3_INT: D5.2 (A), D6.2 (A), U1.78 (GPIO_VREF), U1.84 (+3V3_OUT), U1.86 (+3V3_OUT); also elsewhere on the board
/C1/5V: C1.1, C2.1, C3.1, C4.1, C6.1, U1.77 (+5V_IN), U1.79 (+5V_IN), U1.81 (+5V_IN), U1.83 (+5V_IN), U1.85 (+5V_IN), U1.87 (+5V_IN); also elsewhere on the board
/C1/ETH0+: U1.12 (Ethernet_Pair0_P); also elsewhere on the board
/C1/ETH0-: U1.10 (Ethernet_Pair0_N); also elsewhere on the board
/C1/ETH1+: U1.4 (Ethernet_Pair1_P); also elsewhere on the board
/C1/ETH1-: U1.6 (Ethernet_Pair1_N); also elsewhere on the board
/C1/ETH2+: U1.11 (Ethernet_Pair2_P); also elsewhere on the board
/C1/ETH2-: U1.9 (Ethernet_Pair2_N); also elsewhere on the board
/C1/ETH3+: U1.3 (Ethernet_Pair3_P); also elsewhere on the board
/C1/ETH3-: U1.5 (Ethernet_Pair3_N); also elsewhere on the board
/C1/RPI_PCIe_CLK_N: U1.112 (PCIe_CLK_N), U2.53 (REFCLKN)
/C1/RPI_PCIe_CLK_P: U1.110 (PCIe_CLK_P), U2.55 (REFCLKP)
/C1/RPI_PCIe_CLK_nREQ: U1.102 (PCIe_CLK_nREQ), U2.52 (CLKREQ#/NC)
/C1/RPI_PCIe_RX_N: U1.118 (PCIe_RX_N), U2.41 (PERN0/SATA_B+)
/C1/RPI_PCIe_RX_P: U1.116 (PCIe_RX_P), U2.43 (PERP0/SATA_B-)
/C1/RPI_PCIe_TX_N: U1.124 (PCIe_TX_N), U2.47 (PETN0/SATA_A-)
/C1/RPI_PCIe_TX_P: U1.122 (PCIe_TX_P), U2.49 (PETP0/SATA_A+)
/C1/RPI_PCIe_nRST: U1.109 (PCIe_nRST), U2.50 (PERST#/NC)
/C1/eth_act_ledg: R14.1; also elsewhere on the board
/C1/eth_speed_ledy: R13.1; also elsewhere on the board
/c1_boot: U1.93 (nRPIBOOT); also elsewhere on the board
/c1_rx: U1.51 (GPIO15/UART_RX); also elsewhere on the board
/c1_tx: U1.55 (GPIO14/UART_TX); also elsewhere on the board
/c1_usb+: U1.105 (USB2_P); also elsewhere on the board
/c1_usb-: U1.103 (USB2_N); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), U1.1 (GND), U1.2 (GND), U1.7 (GND), U1.8 (GND), U1.13 (GND), U1.14 (GND), U1.22 (GND), U1.23 (GND), U1.32 (GND), U1.33 (GND), U1.42 (GND), U1.43 (GND), U1.52 (GND), U1.53 (GND), U1.59 (GND), U1.60 (GND), U1.65 (GND), U1.66 (GND), U1.71 (GND), U1.74 (GND), U1.98 (GND), U1.107 (GND), U1.108 (GND), U1.113 (GND), U1.114 (GND), U1.119 (GND), U1.120 (GND), U1.125 (GND), U1.126 (GND), U1.131 (GND), U1.132 (GND), U1.137 (GND), U1.138 (GND), U1.144 (GND), U1.150 (GND), U1.155 (GND), U1.156 (GND), U1.161 (GND), U1.162 (GND), U1.167 (GND), U1.168 (GND), U1.173 (GND), U1.174 (GND), U1.179 (GND), U1.180 (GND), U1.185 (GND), U1.186 (GND), U1.191 (GND), U1.192 (GND), U1.197 (GND), U1.198 (GND), U2.1 (GND), U2.3 (GND), U2.9 (GND), U2.15 (GND), U2.21 (GND), U2.27 (GND), U2.33 (GND), U2.39 (GND), U2.45 (GND), U2.51 (GND), U2.57 (GND)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; also elsewhere on the board
unnamed: D5.1 (K), R7.1
unnamed: D6.1 (K), R12.1
unnamed: JP2.2 (B), U1.91 (BT_nDIsable)
unnamed: JP3.2 (B), U1.89 (WL_nDIsable)
unnamed: JP4.2 (B), U1.20 (EEPROM_nWP)
unnamed: JP5.2 (B), U1.101 (USB_OTG_ID)
unnamed: R7.2, U1.21 (Pi_nLED_Activity)
unnamed: R12.2, U1.19 (Ethernet_nLED1_(speed,yellow,_3.3V))
unnamed: R13.2, U1.17 (Ethernet_nLED2_(speed,yellow,_3.3V))
unnamed: R14.2, U1.15 (Ethernet_nLED3_(act,green,_3.3V))

Parts of its further copies:
C27, C34, C45, C52, C63, C70: 100uF; C_1206_3216Metric; JLC# C312983
C28, C29, C30, C35, C36, C37, C38, C39, C46, C47, C48, C53, C54, C55, C56, C57, C64, C65, C66, C71, C72, C73, C74, C75: 10uF; C_0805_2012Metric; JLC# C15850
C32, C40, C41, C42, C50, C58, C59, C60, C68, C76, C77, C78: 100nF; C_0402_1005Metric; JLC# C1525
D9, D10, D13, D14, D17, D18: LED; LED_0603_1608Metric
J4, J8, J14, J15, J16, J17: DF40HC_3.0_-100DS-0.4V_51_PNP_OVERLAY; HRS_DF40HC(3.0)-100DS-0.4V(58)_PNP_OVERLAY; Manufacturer_Part_Number DF40HC(3.0)-100DS-0.4V(51; Mouser Part Number 798-DF40HC30100DS451
JP7, JP8, JP9, JP10, JP12, JP13, JP14, JP15, JP17, JP18, JP19, JP20: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R28, R42, R56: 1k; R_0402_1005Metric
R33, R34, R35, R47, R48, R49, R61, R62, R63: 470; R_0402_1005Metric; JLC# C25117
U4, U6, U8: rpi_cm4
U5, U7, U9: m.2_pcie_nvme; JLC# C364435

Connections of its further copies:
/C2/3V3: C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, U5.2 (3V3), U5.4 (3V3), U5.12 (3V3), U5.14 (3V3), U5.16 (3V3), U5.18 (3V3), U5.70 (3V3), U5.72 (3V3), U5.74 (3V3); also elsewhere on the board
/C2/3V3_INT: D9.2 (A), D10.2 (A), U4.78 (GPIO_VREF), U4.84 (+3V3_OUT), U4.86 (+3V3_OUT); also elsewhere on the board
/C2/5V: C27.1, C28.1, C29.1, C30.1, C32.1, U4.77 (+5V_IN), U4.79 (+5V_IN), U4.81 (+5V_IN), U4.83 (+5V_IN), U4.85 (+5V_IN), U4.87 (+5V_IN); also elsewhere on the board
/C2/ETH0+: U4.12 (Ethernet_Pair0_P); also elsewhere on the board
/C2/ETH0-: U4.10 (Ethernet_Pair0_N); also elsewhere on the board
/C2/ETH1+: U4.4 (Ethernet_Pair1_P); also elsewhere on the board
/C2/ETH1-: U4.6 (Ethernet_Pair1_N); also elsewhere on the board
/C2/ETH2+: U4.11 (Ethernet_Pair2_P); also elsewhere on the board
/C2/ETH2-: U4.9 (Ethernet_Pair2_N); also elsewhere on the board
/C2/ETH3+: U4.3 (Ethernet_Pair3_P); also elsewhere on the board
/C2/ETH3-: U4.5 (Ethernet_Pair3_N); also elsewhere on the board
/C2/RPI_PCIe_CLK_N: U4.112 (PCIe_CLK_N), U5.53 (REFCLKN)
/C2/RPI_PCIe_CLK_P: U4.110 (PCIe_CLK_P), U5.55 (REFCLKP)
/C2/RPI_PCIe_CLK_nREQ: U4.102 (PCIe_CLK_nREQ), U5.52 (CLKREQ#/NC)
/C2/RPI_PCIe_RX_N: U4.118 (PCIe_RX_N), U5.41 (PERN0/SATA_B+)
/C2/RPI_PCIe_RX_P: U4.116 (PCIe_RX_P), U5.43 (PERP0/SATA_B-)
/C2/RPI_PCIe_TX_N: U4.124 (PCIe_TX_N), U5.47 (PETN0/SATA_A-)
/C2/RPI_PCIe_TX_P: U4.122 (PCIe_TX_P), U5.49 (PETP0/SATA_A+)
/C2/RPI_PCIe_nRST: U4.109 (PCIe_nRST), U5.50 (PERST#/NC)
/C2/eth_act_ledg: R35.1; also elsewhere on the board
/C2/eth_speed_ledy: R34.1; also elsewhere on the board
/C3/3V3: C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, U7.2 (3V3), U7.4 (3V3), U7.12 (3V3), U7.14 (3V3), U7.16 (3V3), U7.18 (3V3), U7.70 (3V3), U7.72 (3V3), U7.74 (3V3); also elsewhere on the board
/C3/3V3_INT: D13.2 (A), D14.2 (A), U6.78 (GPIO_VREF), U6.84 (+3V3_OUT), U6.86 (+3V3_OUT); also elsewhere on the board
/C3/5V: C45.1, C46.1, C47.1, C48.1, C50.1, U6.77 (+5V_IN), U6.79 (+5V_IN), U6.81 (+5V_IN), U6.83 (+5V_IN), U6.85 (+5V_IN), U6.87 (+5V_IN); also elsewhere on the board
/C3/ETH0+: U6.12 (Ethernet_Pair0_P); also elsewhere on the board
/C3/ETH0-: U6.10 (Ethernet_Pair0_N); also elsewhere on the board
/C3/ETH1+: U6.4 (Ethernet_Pair1_P); also elsewhere on the board
/C3/ETH1-: U6.6 (Ethernet_Pair1_N); also elsewhere on the board
/C3/ETH2+: U6.11 (Ethernet_Pair2_P); also elsewhere on the board
/C3/ETH2-: U6.9 (Ethernet_Pair2_N); also elsewhere on the board
/C3/ETH3+: U6.3 (Ethernet_Pair3_P); also elsewhere on the board
/C3/ETH3-: U6.5 (Ethernet_Pair3_N); also elsewhere on the board
/C3/RPI_PCIe_CLK_N: U6.112 (PCIe_CLK_N), U7.53 (REFCLKN)
/C3/RPI_PCIe_CLK_P: U6.110 (PCIe_CLK_P), U7.55 (REFCLKP)
/C3/RPI_PCIe_CLK_nREQ: U6.102 (PCIe_CLK_nREQ), U7.52 (CLKREQ#/NC)
/C3/RPI_PCIe_RX_N: U6.118 (PCIe_RX_N), U7.41 (PERN0/SATA_B+)
/C3/RPI_PCIe_RX_P: U6.116 (PCIe_RX_P), U7.43 (PERP0/SATA_B-)
/C3/RPI_PCIe_TX_N: U6.124 (PCIe_TX_N), U7.47 (PETN0/SATA_A-)
/C3/RPI_PCIe_TX_P: U6.122 (PCIe_TX_P), U7.49 (PETP0/SATA_A+)
/C3/RPI_PCIe_nRST: U6.109 (PCIe_nRST), U7.50 (PERST#/NC)
/C3/eth_act_ledg: R49.1; also elsewhere on the board
/C3/eth_speed_ledy: R48.1; also elsewhere on the board
/C4/3V3: C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, U9.2 (3V3), U9.4 (3V3), U9.12 (3V3), U9.14 (3V3), U9.16 (3V3), U9.18 (3V3), U9.70 (3V3), U9.72 (3V3), U9.74 (3V3); also elsewhere on the board
/C4/3V3_INT: D17.2 (A), D18.2 (A), U8.78 (GPIO_VREF), U8.84 (+3V3_OUT), U8.86 (+3V3_OUT); also elsewhere on the board
/C4/5V: C63.1, C64.1, C65.1, C66.1, C68.1, U8.77 (+5V_IN), U8.79 (+5V_IN), U8.81 (+5V_IN), U8.83 (+5V_IN), U8.85 (+5V_IN), U8.87 (+5V_IN); also elsewhere on the board
/C4/ETH0+: U8.12 (Ethernet_Pair0_P); also elsewhere on the board
/C4/ETH0-: U8.10 (Ethernet_Pair0_N); also elsewhere on the board
/C4/ETH1+: U8.4 (Ethernet_Pair1_P); also elsewhere on the board
/C4/ETH1-: U8.6 (Ethernet_Pair1_N); also elsewhere on the board
/C4/ETH2+: U8.11 (Ethernet_Pair2_P); also elsewhere on the board
/C4/ETH2-: U8.9 (Ethernet_Pair2_N); also elsewhere on the board
/C4/ETH3+: U8.3 (Ethernet_Pair3_P); also elsewhere on the board
/C4/ETH3-: U8.5 (Ethernet_Pair3_N); also elsewhere on the board
/C4/RPI_PCIe_CLK_N: U8.112 (PCIe_CLK_N), U9.53 (REFCLKN)
/C4/RPI_PCIe_CLK_P: U8.110 (PCIe_CLK_P), U9.55 (REFCLKP)
/C4/RPI_PCIe_CLK_nREQ: U8.102 (PCIe_CLK_nREQ), U9.52 (CLKREQ#/NC)
/C4/RPI_PCIe_RX_N: U8.118 (PCIe_RX_N), U9.41 (PERN0/SATA_B+)
/C4/RPI_PCIe_RX_P: U8.116 (PCIe_RX_P), U9.43 (PERP0/SATA_B-)
/C4/RPI_PCIe_TX_N: U8.124 (PCIe_TX_N), U9.47 (PETN0/SATA_A-)
/C4/RPI_PCIe_TX_P: U8.122 (PCIe_TX_P), U9.49 (PETP0/SATA_A+)
/C4/RPI_PCIe_nRST: U8.109 (PCIe_nRST), U9.50 (PERST#/NC)
/C4/eth_act_ledg: R63.1; also elsewhere on the board
/C4/eth_speed_ledy: R62.1; also elsewhere on the board
/c2_boot: U4.93 (nRPIBOOT); also elsewhere on the board
/c2_rx: U4.51 (GPIO15/UART_RX); also elsewhere on the board
/c2_tx: U4.55 (GPIO14/UART_TX); also elsewhere on the board
/c2_usb+: U4.105 (USB2_P); also elsewhere on the board
/c2_usb-: U4.103 (USB2_N); also elsewhere on the board
/c3_boot: U6.93 (nRPIBOOT); also elsewhere on the board
/c3_rx: U6.51 (GPIO15/UART_RX); also elsewhere on the board
/c3_tx: U6.55 (GPIO14/UART_TX); also elsewhere on the board
/c3_usb+: U6.105 (USB2_P); also elsewhere on the board
/c3_usb-: U6.103 (USB2_N); also elsewhere on the board
/c4_boot: U8.93 (nRPIBOOT); also elsewhere on the board
/c4_rx: U8.51 (GPIO15/UART_RX); also elsewhere on the board
/c4_tx: U8.55 (GPIO14/UART_TX); also elsewhere on the board
/c4_usb+: U8.105 (USB2_P); also elsewhere on the board
/c4_usb-: U8.103 (USB2_N); also elsewhere on the board
GND: C27.2, C28.2, C29.2, C30.2, C32.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C45.2, C46.2, C47.2, C48.2, C50.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C63.2, C64.2, C65.2, C66.2, C68.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, JP7.1 (A), JP8.1 (A), JP9.1 (A), JP10.1 (A), JP12.1 (A), JP13.1 (A), JP14.1 (A), JP15.1 (A), JP17.1 (A), JP18.1 (A), JP19.1 (A), JP20.1 (A), U4.1 (GND), U4.2 (GND), U4.7 (GND), U4.8 (GND), U4.13 (GND), U4.14 (GND), U4.22 (GND), U4.23 (GND), U4.32 (GND), U4.33 (GND), U4.42 (GND), U4.43 (GND), U4.52 (GND), U4.53 (GND), U4.59 (GND), U4.60 (GND), U4.65 (GND), U4.66 (GND), U4.71 (GND), U4.74 (GND), U4.98 (GND), U4.107 (GND), U4.108 (GND), U4.113 (GND), U4.114 (GND), U4.119 (GND)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; also elsewhere on the board
unnamed: D9.1 (K), R28.1
unnamed: D10.1 (K), R33.1
unnamed: D13.1 (K), R42.1
unnamed: D14.1 (K), R47.1
unnamed: D17.1 (K), R56.1
unnamed: D18.1 (K), R61.1
unnamed: JP7.2 (B), U4.91 (BT_nDIsable)
unnamed: JP8.2 (B), U4.89 (WL_nDIsable)
unnamed: JP9.2 (B), U4.20 (EEPROM_nWP)
unnamed: JP10.2 (B), U4.101 (USB_OTG_ID)
unnamed: JP12.2 (B), U6.91 (BT_nDIsable)
unnamed: JP13.2 (B), U6.89 (WL_nDIsable)
unnamed: JP14.2 (B), U6.20 (EEPROM_nWP)
unnamed: JP15.2 (B), U6.101 (USB_OTG_ID)
unnamed: JP17.2 (B), U8.91 (BT_nDIsable)
unnamed: JP18.2 (B), U8.89 (WL_nDIsable)
unnamed: JP19.2 (B), U8.20 (EEPROM_nWP)
unnamed: JP20.2 (B), U8.101 (USB_OTG_ID)
unnamed: R28.2, U4.21 (Pi_nLED_Activity)
unnamed: R33.2, U4.19 (Ethernet_nLED1_(speed,yellow,_3.3V))
unnamed: R34.2, U4.17 (Ethernet_nLED2_(speed,yellow,_3.3V))
unnamed: R35.2, U4.15 (Ethernet_nLED3_(act,green,_3.3V))
unnamed: R42.2, U6.21 (Pi_nLED_Activity)
unnamed: R47.2, U6.19 (Ethernet_nLED1_(speed,yellow,_3.3V))
unnamed: R48.2, U6.17 (Ethernet_nLED2_(speed,yellow,_3.3V))
unnamed: R49.2, U6.15 (Ethernet_nLED3_(act,green,_3.3V))
unnamed: R56.2, U8.21 (Pi_nLED_Activity)
unnamed: R61.2, U8.19 (Ethernet_nLED1_(speed,yellow,_3.3V))
unnamed: R62.2, U8.17 (Ethernet_nLED2_(speed,yellow,_3.3V))
unnamed: R63.2, U8.15 (Ethernet_nLED3_(act,green,_3.3V))

Notes on the sheet:
CM4 Decoupling
NVMe Decoupling

Parts:
C81: 100uF; C_1206_3216Metric; JLC# C312983
C82, C83, C84: 10uF; C_0805_2012Metric; JLC# C15850
C86, C88: 100nF; C_0402_1005Metric; JLC# C1525
D21, D22: LED; LED_0603_1608Metric
J13: 0826-1X1T-GH-F; BEL_0826-1X1T-GH-F
J18, J19: DF40HC_3.0_-100DS-0.4V_51_PNP_OVERLAY; HRS_DF40HC(3.0)-100DS-0.4V(58)_PNP_OVERLAY; Manufacturer_Part_Number DF40HC(3.0)-100DS-0.4V(51; Mouser Part Number 798-DF40HC30100DS451
JP22, JP23, JP24, JP25, JP26: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
M1, M2, M3: Fan_4pin; FanPinHeader_1x04_P2.54mm_Vertical
Q1: 2N7002K; SOT-23; JLC# C504047
R70, R75, R78, R80, R82: 1k; R_0402_1005Metric
R71, R72, R73: 470; R_0402_1005Metric
R74: DNP; R_0402_1005Metric
R76: 12K; R_0402_1005Metric; JLC# C25752
R77: 4.7K; R_0402_1005Metric
R79, R81, R83: 0; R_0402_1005Metric; JLC# C17168
U10: rpi_cm4

Connections:
+12V: JP26.1 (A), M1.2 (+), M2.2 (+), M3.2 (+); also elsewhere on the board
/c1_boot: U10.45 (GPIO24); also elsewhere on the board
/c1_rx: U10.55 (GPIO14/UART_TX); also elsewhere on the board
/c1_tx: U10.51 (GPIO15/UART_RX); also elsewhere on the board
/c2_boot: U10.41 (GPIO25); also elsewhere on the board
/c2_rx: U10.54 (GPIO4); also elsewhere on the board
/c2_tx: U10.34 (GPIO5); also elsewhere on the board
/c3_boot: U10.24 (GPIO26); also elsewhere on the board
/c3_disable: U10.46 (GPIO22); also elsewhere on the board
/c3_rx: U10.39 (GPIO8); also elsewhere on the board
/c3_tx: U10.40 (GPIO9); also elsewhere on the board
/c4_boot: U10.48 (GPIO27); also elsewhere on the board
/c4_disable: U10.47 (GPIO23); also elsewhere on the board
/c4_rx: U10.31 (GPIO12); also elsewhere on the board
/c4_tx: U10.28 (GPIO13); also elsewhere on the board
/mgm/5V: C81.1, C82.1, C83.1, C84.1, C86.1, U10.77 (+5V_IN), U10.79 (+5V_IN), U10.81 (+5V_IN), U10.83 (+5V_IN), U10.85 (+5V_IN), U10.87 (+5V_IN); also elsewhere on the board
/mgm/ETH0+: J13.11 (TRD1+), U10.12 (Ethernet_Pair0_P)
/mgm/ETH0-: J13.10 (TRD1-), U10.10 (Ethernet_Pair0_N)
/mgm/ETH1+: J13.4 (TRD2+), U10.4 (Ethernet_Pair1_P)
/mgm/ETH1-: J13.5 (TRD2-), U10.6 (Ethernet_Pair1_N)
/mgm/ETH2+: J13.3 (TRD3+), U10.11 (Ethernet_Pair2_P)
/mgm/ETH2-: J13.2 (TRD3-), U10.9 (Ethernet_Pair2_N)
/mgm/ETH3+: J13.8 (TRD4+), U10.3 (Ethernet_Pair3_P)
/mgm/ETH3-: J13.9 (TRD4-), U10.5 (Ethernet_Pair3_N)
/mgm/USB+: U10.105 (USB2_P); also elsewhere on the board
/mgm/USB-: U10.103 (USB2_N); also elsewhere on the board
/mgm/eth_act_ledg: J13.17, R73.1
/mgm/eth_speed_ledy: J13.20, R72.1
/mgm/fan_pwm_in: M1.4 (PWM), M2.4 (PWM), M3.4 (PWM), Q1.3 (D), R74.2, R76.2, R77.1
/mgm/fanpwm: R74.1, R75.1, U10.49 (GPIO18)
/mgm/pi3V3: D21.2 (A), D22.2 (A), J13.18, J13.19, R78.1, R80.1, R82.1, U10.78 (GPIO_VREF), U10.84 (+3V3_OUT), U10.86 (+3V3_OUT)
/mgm/tach1: R79.1, U10.29 (GPIO16)
/mgm/tach2: R81.1, U10.50 (GPIO17)
/mgm/tach3: R83.1, U10.26 (GPIO19)
GND: C81.2, C82.2, C83.2, C84.2, C86.2, C88.2, J13.S1 (SHIELD), J13.S2 (SHIELD), JP22.1 (A), JP23.1 (A), JP24.1 (A), JP25.1 (A), M1.1 (-), M2.1 (-), M3.1 (-), Q1.2 (S), R77.2, U10.1 (GND), U10.2 (GND), U10.7 (GND), U10.8 (GND), U10.13 (GND), U10.14 (GND), U10.22 (GND), U10.23 (GND), U10.32 (GND), U10.33 (GND), U10.42 (GND), U10.43 (GND), U10.52 (GND), U10.53 (GND), U10.59 (GND), U10.60 (GND), U10.65 (GND), U10.66 (GND), U10.71 (GND), U10.74 (GND), U10.98 (GND), U10.107 (GND), U10.108 (GND), U10.113 (GND), U10.114 (GND), U10.119 (GND), U10.120 (GND), U10.125 (GND), U10.126 (GND), U10.131 (GND), U10.132 (GND), U10.137 (GND), U10.138 (GND), U10.144 (GND), U10.150 (GND), U10.155 (GND), U10.156 (GND), U10.161 (GND), U10.162 (GND), U10.167 (GND), U10.168 (GND), U10.173 (GND), U10.174 (GND), U10.179 (GND), U10.180 (GND), U10.185 (GND), U10.186 (GND), U10.191 (GND), U10.192 (GND), U10.197 (GND), U10.198 (GND); also elsewhere on the board
unnamed: C88.1, J13.1 (TRCT3), J13.6 (TRCT2), J13.7 (TRCT4), J13.12 (TRCT1)
unnamed: D21.1 (K), R70.1
unnamed: D22.1 (K), R71.1
unnamed: JP22.2 (B), U10.91 (BT_nDIsable)
unnamed: JP23.2 (B), U10.89 (WL_nDIsable)
unnamed: JP24.2 (B), U10.20 (EEPROM_nWP)
unnamed: JP25.2 (B), U10.101 (USB_OTG_ID)
unnamed: JP26.2 (B), R76.1
unnamed: M1.3 (Tacho), R78.2, R79.2
unnamed: M2.3 (Tacho), R80.2, R81.2
unnamed: M3.3 (Tacho), R82.2, R83.2
unnamed: Q1.1 (G), R75.2
unnamed: R70.2, U10.21 (Pi_nLED_Activity)
unnamed: R71.2, U10.19 (Ethernet_nLED1_(speed,yellow,_3.3V))
unnamed: R72.2, U10.17 (Ethernet_nLED2_(speed,yellow,_3.3V))
unnamed: R73.2, U10.15 (Ethernet_nLED3_(act,green,_3.3V))

Notes on the sheet:
CM4 Decoupling
UART RX/TX Pairs Swapped in this section.
Two Options to drive Fans. Resistor between fanpwm-fan_pwm_in is to bypass mosfet drive. 12V must be disabled before bypassing.

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
Board: 4 copper layers, 120.0 x 350.0 mm, 248 parts (0 on the bottom side), 241 nets.

## Commit log

2021-08-06 init
2021-08-06 nvme
2021-08-08 Added Schematic Design for 12V->5V DC-DC.
2021-08-08 dcdc: dont use global labels for rails
2021-08-08 add the ksz switch
2021-08-08 possible layout example
2021-08-08 maybe use a premade powerbrick
2021-08-09 just use two usb hubs
2021-08-09 use native rpi uarts instead of extra chip
2021-08-09 Organized DC-DC Schematic.
2021-08-13 Organized sch.
2021-08-13 Organized pi.sch document.
2021-08-13 Revised main schematic.
2021-08-15 move BEL rj45 to dg library
2021-08-15 use a 2x2 and a magjack
2021-08-16 Organized schematics.
2021-08-16 replace fan controller with rpi gpio
    the chip is out of stock until 2022
2021-08-24 Fixed net names.
2021-08-24 Created .gitignore file. Completed schematic organization. Added Fan Driver alternative.
2021-08-24 Schematics annotated.
2021-08-24 Updated PCB Design.
2021-08-28 Completed PCB Placement.
2021-08-30 Fixed fan pwm connection.
2021-08-30 Started Routing.
2021-08-30 Created Net Groups.
2021-08-30 Added 3th Fan Connector.
2021-08-30 Completed PCIE and Eth. Routing.
2021-08-30 Added Power Planes.
2021-08-30 Connected Mgmt. Pi to USB Hub.
2021-08-31 Fixed Eth. Schematic issue and Completed Eth. Routing.
2021-08-31 Added jumper for RJ45 Ind. leds.
2021-08-31 Added PN for PCIE Connector.
2021-08-31 Routed 3V3 Mgmt to RJ45 Connectors.
2021-09-05 Completed Signal & Power Routing.
2021-09-05 Completed USB Hub.
2021-09-05 Adding ground connections.
2021-09-05 Added USB Decouplings.
2021-09-06 Completed Design.Will be reviewed.
2021-09-06 Changed Eth. Led supply to rpi internal 3v3.
2021-09-06 Changed DCDC Disable Signal. Added Labels.
2021-09-11 replace transformers, since out of stock
2021-09-11 fix collision with nvme
2021-09-11 floating all post-transformer ethernet
    as per azonenbergs suggestion,
    external ethernet traces shouldnt use the local ground as reference.
    I have no idea how to calculate the impedance for free floating
    differential pairs. i THINK they need to be treated as single ended?
    but targeting which impedance? 100? 50?
2021-09-13 replace transformer/jack combo with magjack
    we learned from andrew that the pre-transformer length loss isn't actually that bad.
    On the other hand the pre-transformer signals carry alot of EMI.
    I find the EMI more scary because it depends on outside factors,
    while the pre-transformer loss is a work or no-work situation.
2021-09-13 ground fill top and bottom
2021-09-13 Revised layout.
2021-09-13 Changed fuse footprint and updated Part num.
2021-09-14 Added Part numbers.
2021-10-06 thermal relief
2021-10-08 fix #4
2021-10-08 fix #3
2021-10-08 Changed USB Hub with Mux.
2021-10-12 Routing Damned USB Mux.
