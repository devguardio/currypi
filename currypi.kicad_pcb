File: currypi.kicad_pcb (KiCad board)
At the start: 6 copper layers, 120 x 350 mm, 275 parts, among them IC1 OKR-T_6-W12-C, IC10 OKR-T_6-W12-C, IC2 OKR-T_6-W12-C, IC3 OKR-T_6-W12-C, IC4 OKR-T_6-W12-C, IC5 OKR-T_6-W12-C, IC6 OKR-T_6-W12-C, IC7 OKR-T_6-W12-C, IC8 OKR-T_6-W12-C, IC9 OKR-T_6-W12-C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

Commit message: Added jumper for RJ45 Ind. leds.
Parts:
- added JP27: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm, F.Cu at (168.4, 310.7)
- moved JP2 16.4 mm to (148.7, 112.6)
- moved JP3 16.4 mm to (148.7, 110.1)
- moved JP4 16.4 mm to (148.7, 107.6)
- moved JP5 16.4 mm to (148.7, 105.1)
- moved JP10 15.4 mm to (147.7, 174.4)
- moved JP7 15.4 mm to (147.7, 181.9)
- moved JP8 15.4 mm to (147.7, 179.4)
- moved JP9 15.4 mm to (147.7, 176.9)
Routing:
- net /c1_usb+: track 0.00 -> 187.4 mm
- net /c1_usb-: track 0.00 -> 186.2 mm
- net /c2_usb+: track 0.00 -> 126.5 mm
- net /c2_usb-: track 0.00 -> 125.3 mm
- net /c4_usb+: track 0.00 -> 102.5 mm
- net /c4_usb-: track 0.00 -> 101.3 mm
- net /c3_usb+: track 0.00 -> 94.3 mm
- net /c3_usb-: track 0.00 -> 93.1 mm
- net (no net): track 92.2 -> 0.00 mm
- net /mgm/tach2: track 5.41 -> 0.00 mm
- net /mgm/tach1: track 5.20 -> 0.00 mm
- net /mgm/pi3V3: track 16.9 -> 12.0 mm
- net Net-(C79-Pad2): track 4.53 -> 0.00 mm
- net Net-(C61-Pad2): track 4.53 -> 0.01 mm
Other:
- board size 120 x 350 mm -> 120 x 576.5 mm

Commit message: Added PN for PCIE Connector.
Parts:
- moved JP27 73.5 mm to (172.6, 384.1)
Other:
- board size 120 x 576.5 mm -> 120 x 350 mm

Commit message: Routed 3V3 Mgmt to RJ45 Connectors.
Parts:
- moved JP27 72.9 mm to (115.3, 339.0), turned to 90 degrees
Routing:
- net /LED_3V3: track 0.00 -> 90.9 mm, vias 0 -> 1
- net /mgm/pi3V3: track 12.0 -> 67.7 mm, vias 1 -> 2
- net Net-(C88-Pad1): track 0.00 -> 22.4 mm
- net GND: track 0.00 -> 0.82 mm, vias 16 -> 17
Other:
- copper layers 6 -> 4
Changed lines of the file:
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@@
     (thickness 1.6)
     (drawings 10)
-    (tracks 7588)
+    (tracks 7638)
     (zones 0)
     (modules 276)
@@
     (1 In1.Cu power)
     (2 In2.Cu power)
-    (3 In3.Cu power)
-    (4 In4.Cu power)
     (31 B.Cu signal)
     (32 B.Adhes user)
@@
     (39 F.Mask user)
     (40 Dwgs.User user hide)
-    (41 Cmts.User user hide)
-    (42 Eco1.User user hide)
-    (43 Eco2.User user hide)
+    (41 Cmts.User user)
+    (42 Eco1.User user)
+    (43 Eco2.User user)
     (44 Edge.Cuts user)
     (45 Margin user)
@@
   )
   (setup
-    (last_trace_width 0.11)
+    (last_trace_width 0.5)
     (user_trace_width 0.15)
     (user_trace_width 0.25)
@@
   )
   (module Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm (layer F.Cu)
-    (at 172.6 384.1)
+    (at 115.3 339 90)
     (descr "SMD Solder Jumper, 1x1.5mm, rounded Pads, 0.3mm gap, open")
     (tags "solder jumper open")
     (attr virtual)
-    (fp_text reference JP27 (at 0 -1.8) (layer F.SilkS)
+    (fp_text reference JP27 (at 0 -1.8 90) (layer F.SilkS)
       (effects (font (size 0.6 0.6) (thickness 0.1)))
     )
-    (fp_text value SolderJumper_2_Open (at 0 1.9) (layer F.Fab)
+    (fp_text value SolderJumper_2_Open (at 0 1.9 90) (layer F.Fab)
       (effects (font (size 1 1) (thickness 0.15)))
     )
@@
     (fp_arc (start 0.7 0.3) (end 0.7 1) (angle -90) (layer F.SilkS) (width 0.12))
     (fp_arc (start 0.7 -0.3) (end 1.4 -0.3) (angle -90) (layer F.SilkS) (width 0.12))
-    (pad 2 smd custom (at 0.65 0) (size 1 0.5) (layers F.Cu F.Mask)
+    (pad 2 smd custom (at 0.65 0 90) (size 1 0.5) (layers F.Cu F.Mask)
       (net 4 /3V3_MGMT) (zone_connect 2)
       (options (clearance outline) (anchor rect))
@@
            (xy 0 -0.75) (xy -0.5 -0.75) (xy -0.5 0.75) (xy 0 0.75)) (width 0))
       ))
-    (pad 1 smd custom (at -0.65 0) (size 1 0.5) (layers F.Cu F.Mask)
+    (pad 1 smd custom (at -0.65 0 90) (size 1 0.5) (layers F.Cu F.Mask)
       (net 459 /LED_3V3) (zone_connect 2)
       (options (clearance outline) (anchor rect))
@@
   (via (at 105.5 122.5) (size 0.45) (drill 0.2) (layers F.Cu B.Cu) (net 1))
   (via (at 107.5 122.5) (size 0.45) (drill 0.2) (layers F.Cu B.Cu) (net 1))
+  (via (at 134.2 346.5) (size 0.5) (drill 0.2) (layers F.Cu B.Cu) (net 1))
+  (segment (start 134.2 345.68) (end 134.2 346.5) (width 0.5) (layer F.Cu) (net 1))
   (segment (start 92.99 113.485) (end 93 113.475) (width 0.5) (layer F.Cu) (net 2))
   (segment (start 92.99 118) (end 92.99 113.485) (width 0.5) (layer F.Cu) (net 2))
@@
   (segment (start 99 317.5) (end 99 316.73) (width 0.25) (layer F.Cu) (net 15))
   (segment (start 99 318.912) (end 99 317.5) (width 0.25) (layer F.Cu) (net 15))
+  (segment (start 118.904 346.244) (end 119.92 347.26) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 118.904 344.72) (end 118.904 346.244) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 119.92 347.26) (end 119.92 348.42) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 119.92 348.42) (end 121 349.5) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 121 349.5) (end 129 349.5) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 130.08 348.42) (end 130.08 347.26) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 129 349.5) (end 130.08 348.42) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 131.096 346.244) (end 130.08 347.26) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 131.096 344.72) (end 131.096 346.244) (width 0.5) (layer F.Cu) (net 17))
+  (segment (start 131.096 344.72) (end 134.2 344.72) (width 0.5) (layer F.Cu) (net 17))
   (segment (start 115.6 29) (end 112.25 29) (width 0.5) (layer F.Cu) (net 18))
   (segment (start 110.46 27.21) (end 110.46 25) (width 0.5) (layer F.Cu) (net 18))
@@
   (segment (start 164 348.1) (end 164 348.6) (width 0.25) (layer F.Cu) (net 37))
   (segment (start 164 348.6) (end 164 348.8) (width 0.25) (layer F.Cu) (net 37))
+  (segment (start 121.444 342.18) (end 128.556 342.18) (width 0.5) (layer In2.Cu) (net 37))
+  (segment (start 129.973999 343.597999) (end 128.556 342.18) (width 0.5) (layer In2.Cu) (net 37))
+  (segment (start 141.097999 343.597999) (end 129.973999 343.597999) (width 0.5) (layer In2.Cu) (net 37))
+  (segment (start 146 348.5) (end 141.097999 343.597999) (width 0.5) (layer In2.Cu) (net 37))
+  (via (at 151.9 340.6) (size 0.5) (drill 0.2) (layers F.Cu B.Cu) (net 37))
+  (segment (start 151.9 348.5) (end 151.9 340.6) (width 0.5) (layer In2.Cu) (net 37))
+  (segment (start 164 348.5) (end 151.9 348.5) (width 0.5) (layer In2.Cu) (net 37))
+  (segment (start 151.9 348.5) (end 146 348.5) (width 0.5) (layer In2.Cu) (net 37))
+  (segment (start 151.9 339.5125) (end 151.9125 339.5) (width 0.5) (layer F.Cu) (net 37))
+  (segment (start 151.9 340.6) (end 151.9 339.5125) (width 0.5) (layer F.Cu) (net 37))
+  (segment (start 151.9125 339.5) (end 151.9125 337.9) (width 0.5) (layer F.Cu) (net 37))
   (segment (start 154.0875 338.9) (end 153.4875 339.5) (width 0.15) (layer F.Cu) (net 38))
   (segment (start 156.59 338.9) (end 154.0875 338.9) (width 0.15) (layer F.Cu) (net 38))
@@
   (segment (start 124.749556 152.780366) (end 113.149556 152.780366) (width 0.124968) (layer F.Cu) (net 250))
   (segment (start 109.650444 141.919634) (end 110.090366 142.359556) (width 0.124968) (layer F.Cu) (net 250))
+  (segment (start 83.58 350.8144) (end 83.58 354.22) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 83.58 354.22) (end 81.7 356.1) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 83.58 365.4956) (end 81.7 363.6156) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 81.7 359.5) (end 86 359.5) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 81.7 363.6156) (end 81.7 359.5) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 81.7 359.5) (end 81.7 356.1) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 89.5318 363.0318) (end 94.4512 363.0318) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 86 359.5) (end 89.5318 363.0318) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 96.9912 360.4918) (end 98.0834 360.4918) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 94.4512 363.0318) (end 96.9912 360.4918) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 97.55 352.0844) (end 97.55 349.5444) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 97.55 352.0844) (end 99.3 353.8344) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 99.3 359.2752) (end 98.0834 360.4918) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 99.3 353.8344) (end 99.3 359.2752) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 98.0834 360.4918) (end 103.0872 365.4956) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 111.52 354.6244) (end 110 356.1444) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 110 356.1444) (end 110 358.8) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 106.9044 361.8956) (end 106.9044 365.4956) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 110 358.8) (end 106.9044 361.8956) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 106.9044 365.4956) (end 108.98 365.4956) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 103.0872 365.4956) (end 106.9044 365.4956) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 111.52 354.6244) (end 113.7756 354.6244) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 113.7756 354.6244) (end 115.3 353.1) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 115.3 353.1) (end 115.3 341.3) (width 0.5) (layer In2.Cu) (net 459))
+  (via (at 115.3 341) (size 0.5) (drill 0.2) (layers F.Cu B.Cu) (net 459))
+  (segment (start 115.3 341.3) (end 115.3 341) (width 0.5) (layer In2.Cu) (net 459))
+  (segment (start 115.3 341) (end 115.3 339.65) (width 0.5) (layer F.Cu) (net 459))
   (segment (start 115 24) (end 114.25 23.25) (width 0.25) (layer F.Cu) (net 466))
   (segment (start 109.67 23.25) (end 107.92 25) (width 0.25) (layer F.Cu) (net 466))

Commit message: Completed Signal & Power Routing.
Parts:
- removed TP1, TP10, TP11, TP12, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9: TestPoint, TestPoint:TestPoint_Pad_D1.0mm
- moved JP5 45.5 mm to (113.8, 76.0)
- moved JP10 44.6 mm to (113.8, 145.5)
- moved JP25 36.4 mm to (191.0, 334.4), turned to 90 degrees
- moved JP4 35.9 mm to (113.2, 101.8), turned to 270 degrees
- moved JP9 34.9 mm to (113.2, 171.2), turned to 270 degrees
- moved JP15 30.3 mm to (113.8, 215.5)
- moved JP20 30.3 mm to (113.8, 284.5)
- moved JP24 22.8 mm to (171.6, 334.4), turned to 180 degrees
- moved JP14 20.3 mm to (113.2, 241.2), turned to 270 degrees
- moved JP19 20.3 mm to (113.2, 310.2), turned to 270 degrees
- moved JP3 18.3 mm to (132.2, 102.2), turned to 270 degrees
- moved JP2 17.5 mm to (134.7, 102.2), turned to 270 degrees
- moved JP8 17.2 mm to (132.2, 171.9), turned to 270 degrees
- moved R1 17.1 mm to (150.0, 91.6)
- moved R2 16.9 mm to (150.0, 74.6)
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Routing:
- net /mgm/tach1: track 0.00 -> 369.8 mm, vias 0 -> 2
- net /mgm/tach3: track 0.00 -> 359.2 mm, vias 0 -> 6
- net /mgm/tach2: track 0.00 -> 354.1 mm, vias 0 -> 2
- net /mgm/pi3V3: track 67.7 -> 421.4 mm, vias 2 -> 4
- net /mgm/fanpwm: track 4.21 -> 352.8 mm, vias 0 -> 2
- net /c1_tx: track 0.00 -> 293.6 mm, vias 0 -> 6
- net /c1_boot: track 0.00 -> 292.2 mm, vias 0 -> 6
- net /c1_rx: track 0.00 -> 291.1 mm, vias 0 -> 6
- net /C1/eth_act_ledg: track 0.00 -> 286.5 mm, vias 0 -> 2
- net /c1_disable: track 0.00 -> 285.8 mm, vias 0 -> 6
- net /C1/eth_speed_ledy: track 0.00 -> 275.8 mm, vias 0 -> 2
- net /C2/eth_act_ledg: track 0.00 -> 215.3 mm, vias 0 -> 3
- net /c2_disable: track 0.00 -> 209.2 mm, vias 0 -> 4
- net /C2/eth_speed_ledy: track 0.00 -> 202.4 mm, vias 0 -> 2
- net /c2_boot: track 0.00 -> 201.0 mm, vias 0 -> 4
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- added copper zone on In2.Cu, net +12V
- added copper zone on In2.Cu, net /C1/3V3
- added copper zone on In2.Cu, net /C1/5V
- added copper zone on In2.Cu, net /C1_PWR/VIN_DCDC_3V3
- added copper zone on F.Cu, net /C1_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /C1_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /C2/3V3
- added copper zone on In2.Cu, net /C2/5V
- added copper zone on In2.Cu, net /C2_PWR/VIN_DCDC_3V3
- added copper zone on F.Cu, net /C2_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /C2_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /C3/3V3
- added copper zone on In2.Cu, net /C3/5V
- added copper zone on In2.Cu, net /C3_PWR/VIN_DCDC_3V3
- added copper zone on F.Cu, net /C3_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /C3_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /C4/3V3
- added copper zone on In2.Cu, net /C4/5V
- added copper zone on In2.Cu, net /C4_PWR/VIN_DCDC_3V3
- added copper zone on F.Cu, net /C4_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /C4_PWR/VIN_DCDC_5V
- added copper zone on In2.Cu, net /mgm/5V
- added copper zone on F.Cu, net /sheet614B5146/VIN_DCDC_5V
- added copper zone on In2.Cu, net /sheet614B5146/VIN_DCDC_5V
- added copper zone on In1.Cu, net GND

Commit message: Completed USB Hub.
Parts:
- added C5: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (179.7, 232.5)
- added C7: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (186.7, 229.7)
- moved R19 0.50 mm to (185.2, 223.5)
- moved R18 0.20 mm to (186.7, 228.7)
Routing:
- net /3V3_MGMT: track 149.1 -> 263.1 mm, vias 1 -> 11
- net GND: track 104.7 -> 124.6 mm, vias 54 -> 73
- net /usbhub/XTALOUT: track 0.00 -> 6.71 mm
- net /usbhub/XTALIN: track 0.00 -> 5.71 mm
- net /usbhub/USB_Hub_RSTn: track 0.00 -> 4.93 mm
- net Net-(C24-Pad1): track 0.00 -> 2.67 mm
- net Net-(R19-Pad2): track 0.00 -> 2.23 mm
- net Net-(R16-Pad2): track 0.00 -> 2.06 mm
- net Net-(C25-Pad1): track 0.00 -> 1.59 mm
- net Net-(R17-Pad2): track 0.00 -> 1.55 mm
- net Net-(R18-Pad2): track 0.00 -> 1.42 mm
- net Net-(R20-Pad2): track 0.00 -> 1.38 mm
- net Net-(R21-Pad2): track 0.00 -> 1.34 mm
- net /c1_usb-: track 189.7 -> 190.5 mm
- net /c1_usb+: track 190.9 -> 191.7 mm
- added copper zone on F.Cu, net /3V3_MGMT
- added copper zone on In2.Cu, net /3V3_MGMT

Commit message: Adding ground connections.
Routing:
- net GND: track 124.6 -> 272.7 mm, vias 73 -> 121
- net /mgm/5V: track 26.7 -> 78.9 mm
- net /c1_boot: track 292.2 -> 292.8 mm
- net /mgm/tach3: track 359.2 -> 359.8 mm
- added copper zone on In2.Cu, net GND
