# Repository devguardio/currypi

## KiCad design currypi.kicad_pcb

Parts:
C17, C18, C31, C33: 100nF; C_0402_1005Metric; JLC# C1525
D1, D2: D_TVS; D_SMA; LCSC# C484334
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3_Pad
J5, J6: Conn_02x04_Odd_Even; Molex_Mini-Fit_Jr_5569-08A2_2x04_P4.20mm_Horizontal
J20: 0879-2C2R-54; BEL_0879-2C2R-54; PARTREV C
LOGO1: Logo_Open_Hardware_Small; OSHW-Logo2_9.8x8mm_SilkScreen

Connections:
+12V: D1.1 (A1), D2.1 (A1), J5.5, J5.6, J5.7, J5.8, J6.5, J6.6, J6.7, J6.8; also elsewhere on the board
/C1/3V3_INT: J20.11_1, J20.14_1; also elsewhere on the board
/C1/ETH0+: J20.2_1 (TRD1+_1); also elsewhere on the board
/C1/ETH0-: J20.1_1 (TRD1-_1); also elsewhere on the board
/C1/ETH1+: J20.4_1 (TRD2+_1); also elsewhere on the board
/C1/ETH1-: J20.3_1 (TRD2-_1); also elsewhere on the board
/C1/ETH2+: J20.6_1 (TRD3+_1); also elsewhere on the board
/C1/ETH2-: J20.5_1 (TRD3-_1); also elsewhere on the board
/C1/ETH3+: J20.8_1 (TRD4+_1); also elsewhere on the board
/C1/ETH3-: J20.7_1 (TRD4-_1); also elsewhere on the board
/C1/eth_act_ledg: J20.13_1; also elsewhere on the board
/C1/eth_speed_ledy: J20.12_1; also elsewhere on the board
/C2/3V3_INT: J20.11_2, J20.14_2; also elsewhere on the board
/C2/ETH0+: J20.2_2 (TRD1+_2); also elsewhere on the board
/C2/ETH0-: J20.1_2 (TRD1-_2); also elsewhere on the board
/C2/ETH1+: J20.4_2 (TRD2+_2); also elsewhere on the board
/C2/ETH1-: J20.3_2 (TRD2-_2); also elsewhere on the board
/C2/ETH2+: J20.6_2 (TRD3+_2); also elsewhere on the board
/C2/ETH2-: J20.5_2 (TRD3-_2); also elsewhere on the board
/C2/ETH3+: J20.8_2 (TRD4+_2); also elsewhere on the board
/C2/ETH3-: J20.7_2 (TRD4-_2); also elsewhere on the board
/C2/eth_act_ledg: J20.13_2; also elsewhere on the board
/C2/eth_speed_ledy: J20.12_2; also elsewhere on the board
/C3/3V3_INT: J20.11_3, J20.14_3; also elsewhere on the board
/C3/ETH0+: J20.2_3 (TRD1+_3); also elsewhere on the board
/C3/ETH0-: J20.1_3 (TRD1-_3); also elsewhere on the board
/C3/ETH1+: J20.4_3 (TRD2+_3); also elsewhere on the board
/C3/ETH1-: J20.3_3 (TRD2-_3); also elsewhere on the board
/C3/ETH2+: J20.6_3 (TRD3+_3); also elsewhere on the board
/C3/ETH2-: J20.5_3 (TRD3-_3); also elsewhere on the board
/C3/ETH3+: J20.8_3 (TRD4+_3); also elsewhere on the board
/C3/ETH3-: J20.7_3 (TRD4-_3); also elsewhere on the board
/C3/eth_act_ledg: J20.13_3; also elsewhere on the board
/C3/eth_speed_ledy: J20.12_3; also elsewhere on the board
/C4/3V3_INT: J20.11_4, J20.14_4; also elsewhere on the board
/C4/ETH0+: J20.2_4 (TRD1+_4); also elsewhere on the board
/C4/ETH0-: J20.1_4 (TRD1-_4); also elsewhere on the board
/C4/ETH1+: J20.4_4 (TRD2+_4); also elsewhere on the board
/C4/ETH1-: J20.3_4 (TRD2-_4); also elsewhere on the board
/C4/ETH2+: J20.6_4 (TRD3+_4); also elsewhere on the board
/C4/ETH2-: J20.5_4 (TRD3-_4); also elsewhere on the board
/C4/ETH3+: J20.8_4 (TRD4+_4); also elsewhere on the board
/C4/ETH3-: J20.7_4 (TRD4-_4); also elsewhere on the board
/C4/eth_act_ledg: J20.13_4; also elsewhere on the board
/C4/eth_speed_ledy: J20.12_4; also elsewhere on the board
GND: C17.2, C18.2, C31.2, C33.2, D1.2 (A2), D2.2 (A2), H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J5.1, J5.2, J5.3, J5.4, J6.1, J6.2, J6.3, J6.4, J20.10_1 (GND_1), J20.10_2 (GND_2), J20.10_3 (GND_3), J20.10_4 (GND_4), J20.S1 (SHIELD), J20.S2 (SHIELD), J20.S3 (SHIELD), J20.S4 (SHIELD), J20.S5 (SHIELD); also elsewhere on the board
unnamed: C17.1, J20.9_1 (TRDCT1/2/3/4_1)
unnamed: C18.1, J20.9_2 (TRDCT1/2/3/4_2)
unnamed: C31.1, J20.9_3 (TRDCT1/2/3/4_3)
unnamed: C33.1, J20.9_4 (TRDCT1/2/3/4_4)

Notes on the sheet:
TODO: replace usb hub with mux TODO: dont place components under nvme TODO: cannot connect enable/disable pin of two power modules TODO: uart c2,c3,c4 are swapped TODO: c1 is unreliable. should we use a separate uart chip? TODO: can we use uart2? TODO: switch to link-pp magjack TODO: thermal relief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

Parts:
C5, C7, C19: 100nF; C_0402_1005Metric
R8, R9, R10, R11, R15, R16: 10k; R_0402_1005Metric
U3, U11, U12: FSUSB30MUX; MSOP-10_3x3mm_P0.5mm

Connections:
/3V3_MGMT: C5.1, C7.1, C19.1, R15.2, R16.2, U3.10 (VCC), U11.10 (VCC), U12.10 (VCC); also elsewhere on the board
/c1_usb+: U11.2 (HSD1+); also elsewhere on the board
/c1_usb-: U11.8 (HSD1-); also elsewhere on the board
/c2_usb+: U11.3 (HSD2+); also elsewhere on the board
/c2_usb-: U11.7 (HSD2-); also elsewhere on the board
/c3_usb+: U12.2 (HSD1+); also elsewhere on the board
/c3_usb-: U12.8 (HSD1-); also elsewhere on the board
/c4_usb+: U12.3 (HSD2+); also elsewhere on the board
/c4_usb-: U12.7 (HSD2-); also elsewhere on the board
/mgm/USB+: U3.4 (D+); also elsewhere on the board
/mgm/USB-: U3.6 (D-); also elsewhere on the board
/usbhub/USB_SW_OE1: R15.1, U11.9 (OE)
/usbhub/USB_SW_OE2: R16.1, U12.9 (OE)
/usbhub/root_usb_enable: R8.1, U3.9 (OE)
/usbhub/root_usb_sel0: R9.1, U3.1 (Select)
/usbhub/root_usb_sel1: R10.1, U11.1 (Select)
/usbhub/root_usb_sel2: R11.1, U12.1 (Select)
/usbhub/usb_sw0_sw1+: U3.2 (HSD1+), U11.4 (D+)
/usbhub/usb_sw0_sw1-: U3.8 (HSD1-), U11.6 (D-)
/usbhub/usb_sw0_sw2+: U3.3 (HSD2+), U12.4 (D+)
/usbhub/usb_sw0_sw2-: U3.7 (HSD2-), U12.6 (D-)
GND: C5.2, C7.2, C19.2, R8.2, R9.2, R10.2, R11.2, U3.5 (GND), U11.5 (GND), U12.5 (GND); also elsewhere on the board

Notes on the sheet:
OE1 & OE2 is not used.
In default output is disabled (OE0).

Parts:
D3, D4: LED; LED_0603_1608Metric
F1: Polyfuse; Fuse_2920_7451Metric_Castellated; JLC# C315905
IC1, IC2: OKR-T_6-W12-C; MURATACASEC90; Manufacturer_Part_Number OKR-T/6-W12-C; Mouser Part Number 580-OKR-T/6-W12-C
J7: Header_2x6_2.54mm; PinHeader_2x03_P2.54mm_Vertical
JP6: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 261; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; JLC# C25097
R2: 432; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; JLC# C100430
R3: 1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4, R5: 1k; R_0402_1005Metric
R6: 100k; R_0402_1005Metric
RLA1: G3VM-61VY2-TR; G3VM-SOP; LCSC# C306896

Connections:
+12V: F1.1; also elsewhere on the board
/C1/3V3: D4.2 (A), IC2.4 (+VOUT); also elsewhere on the board
/C1/5V: D3.2 (A), IC1.4 (+VOUT), J7.1, J7.2; also elsewhere on the board
/C1_PWR/VIN_DCDC_3V3: IC2.2 (+VIN), J7.3, J7.4
/C1_PWR/VIN_DCDC_5V: F1.2, IC1.2 (+VIN), J7.5, J7.6
GND: IC1.3 (GROUND), IC2.3 (GROUND), R1.1, R2.1, R4.2, R5.2, R6.2, RLA1.2, RLA1.3; also elsewhere on the board
unnamed: D3.1 (K), R4.1
unnamed: D4.1 (K), R5.1
unnamed: IC1.5 (OUTPUT_TRIM), R1.2
unnamed: IC2.5 (OUTPUT_TRIM), R2.2
unnamed: R3.2, R6.1, RLA1.1

Parts of its further copies:
D7, D8, D11, D12, D15, D16, D19, D20: LED; LED_0603_1608Metric
F2, F3, F4, F5: Polyfuse; Fuse_2920_7451Metric_Castellated; JLC# C315905
IC3, IC4, IC5, IC6, IC7, IC8, IC9, IC10: OKR-T_6-W12-C; MURATACASEC90; Manufacturer_Part_Number OKR-T/6-W12-C; Mouser Part Number 580-OKR-T/6-W12-C
J9, J10, J11, J12: Header_2x6_2.54mm; PinHeader_2x03_P2.54mm_Vertical
JP1, JP11, JP16, JP21: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R22, R36, R50, R64: 261; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; JLC# C25097
R23, R37, R51, R65: 432; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; JLC# C100430
R24, R38, R52, R66: 1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R25, R26, R39, R40, R53, R54, R67, R68: 1k; R_0402_1005Metric
R27, R41, R55, R69: 100k; R_0402_1005Metric
RLA2, RLA3, RLA4, RLA5: G3VM-61VY2-TR; G3VM-SOP; LCSC# C306896

Connections of its further copies:
+12V: F2.1, F3.1, F4.1, F5.1; also elsewhere on the board
/3V3_MGMT: D20.2 (A), IC10.4 (+VOUT); also elsewhere on the board
/C2/3V3: D8.2 (A), IC4.4 (+VOUT); also elsewhere on the board
/C2/5V: D7.2 (A), IC3.4 (+VOUT), J9.1, J9.2; also elsewhere on the board
/C2_PWR/VIN_DCDC_3V3: IC4.2 (+VIN), J9.3, J9.4
/C2_PWR/VIN_DCDC_5V: F2.2, IC3.2 (+VIN), J9.5, J9.6
/C3/3V3: D12.2 (A), IC6.4 (+VOUT); also elsewhere on the board
/C3/5V: D11.2 (A), IC5.4 (+VOUT), J10.1, J10.2; also elsewhere on the board
/C3_PWR/DISABLE_DCDC: IC5.1 (REMOTE_ON/OFF_CONTROL), IC6.1 (REMOTE_ON/OFF_CONTROL), JP11.2 (B), RLA3.4
/C3_PWR/VIN_DCDC_3V3: IC6.2 (+VIN), J10.3, J10.4
/C3_PWR/VIN_DCDC_5V: F3.2, IC5.2 (+VIN), J10.5, J10.6
/C4/3V3: D16.2 (A), IC8.4 (+VOUT); also elsewhere on the board
/C4/5V: D15.2 (A), IC7.4 (+VOUT), J11.1, J11.2; also elsewhere on the board
/C4_PWR/DISABLE_DCDC: IC7.1 (REMOTE_ON/OFF_CONTROL), IC8.1 (REMOTE_ON/OFF_CONTROL), JP16.2 (B), RLA4.4
/C4_PWR/VIN_DCDC_3V3: IC8.2 (+VIN), J11.3, J11.4
/C4_PWR/VIN_DCDC_5V: F4.2, IC7.2 (+VIN), J11.5, J11.6
/c3_disable: JP11.1 (A), R38.1; also elsewhere on the board
/c4_disable: JP16.1 (A), R52.1; also elsewhere on the board
/mgm/5V: D19.2 (A), IC9.4 (+VOUT), J12.1, J12.2; also elsewhere on the board
/sheet614B5146/DISABLE: JP21.1 (A), R66.1
/sheet614B5146/DISABLE_DCDC: IC9.1 (REMOTE_ON/OFF_CONTROL), IC10.1 (REMOTE_ON/OFF_CONTROL), JP21.2 (B), RLA5.4
/sheet614B5146/VIN_DCDC_3V3: IC10.2 (+VIN), J12.3, J12.4
/sheet614B5146/VIN_DCDC_5V: F5.2, IC9.2 (+VIN), J12.5, J12.6
GND: IC3.3 (GROUND), IC4.3 (GROUND), IC5.3 (GROUND), IC6.3 (GROUND), IC7.3 (GROUND), IC8.3 (GROUND), IC9.3 (GROUND), IC10.3 (GROUND), R22.1, R23.1, R25.2, R26.2, R27.2, R36.1, R37.1, R39.2, R40.2, R41.2, R50.1, R51.1, R53.2, R54.2, R55.2, R64.1, R65.1, R67.2, R68.2, R69.2, RLA2.2, RLA2.3, RLA3.2, RLA3.3, RLA4.2, RLA4.3, RLA5.2, RLA5.3; also elsewhere on the board
unnamed: D7.1 (K), R25.1
unnamed: D8.1 (K), R26.1
unnamed: D11.1 (K), R39.1
unnamed: D12.1 (K), R40.1
unnamed: D15.1 (K), R53.1
unnamed: D16.1 (K), R54.1
unnamed: D19.1 (K), R67.1
unnamed: D20.1 (K), R68.1
unnamed: IC3.5 (OUTPUT_TRIM), R22.2
unnamed: IC4.5 (OUTPUT_TRIM), R23.2
unnamed: IC5.5 (OUTPUT_TRIM), R36.2
unnamed: IC6.5 (OUTPUT_TRIM), R37.2
unnamed: IC7.5 (OUTPUT_TRIM), R50.2
unnamed: IC8.5 (OUTPUT_TRIM), R51.2
unnamed: IC9.5 (OUTPUT_TRIM), R64.2
unnamed: IC10.5 (OUTPUT_TRIM), R65.2
unnamed: R24.2, R27.1, RLA2.1
unnamed: R38.2, R41.1, RLA3.1
unnamed: R52.2, R55.1, RLA4.1
unnamed: R66.2, R69.1, RLA5.1

Notes on the sheet:
Best efficiency isnt entirely clear yet, We can switch input for 3.3 between 5V and 12V here
RTRIM (kOhm) = 1.182 / (Vout-0.591)
RTRIM_3V3 = 432 = 1.182 / (3.32-0.591)
RTRIM_5V = 261 = 1.182 / (5.11-0.591)
Jumper to Bypass Mosfet Disable Control.
